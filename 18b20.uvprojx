# Keil uVision project 18b20.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 18b20 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\lib;.\system;.\user;.\lib\inc;.\Ethernet
  asm include: .\asm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group asm
    ./asm/: startup_stm32f10x_hd.s
  group system
    ./system/: core_cm3.c system_stm32f10x.c
  group lib
    ./lib/src/: misc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_can.c stm32f10x_dma.c
  group user
    ./user/: main.c stm32f10x_it.c pbdata.c led.c usart.c tim.c spi.c loopback.c
    ./: net.c
  group Ethernet
    ./Ethernet/: socket.c wizchip_conf.c
    ./Ethernet/W5500/: w5500.c
